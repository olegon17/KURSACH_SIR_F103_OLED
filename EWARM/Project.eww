<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\KURSACH_SIR_F103_OLED.ewp</path>
  </project>
  <batchBuild />
</workspace>
